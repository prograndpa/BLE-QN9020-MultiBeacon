# Keil uVision project broadcaster.uvproj, settings and files
target broadcaster (ARM-ADS)
  device: QN9020 NXP
  cpu: IRAM(0x00008000-0x0000FFFF) IROM(0x00000000-0x00007FFF) CLOCK(16000000) CPUTYPE("Cortex-M0")
  output: broadcaster
  AfterMake: fromelf --bin --output ./bin/broadcaster.bin ./obj/broadcaster.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c misc: --C99
  c include: ..\..\src\fw;..\..\src\profiles;..\..\src\app;..\..\src\app\gatt;..\..\src\app\smp;..\..\src\cmsis;..\..\src\driver;..\..\src\lib;..\..\src\qnevb;..\src;..\..\src\app\gap
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x8000 size 0x8000
  scatter file: ..\..\src\link\keil\qn9020_link.sct
  link misc: --no_autoat --remove
  group startup
    ../../src/startup/keil/: startup.s
  group main
    ../../src/main/: app_main.c
  group usr
    ../src/: system.c usr_design.c
  group app
    ../../src/app/: app_task.c
    ../../src/app/gap/: app_gap.c app_gap_task.c
  group drivers
    ../../src/driver/: uart.c gpio.c sleep.c syscon.c timer.c rtc.c serialflash.c
  group lib
    ../../src/lib/keil/: qn9020b2_lib_peripheral.lib qn9020b4_lib_peripheral.lib
  group qnevb
    ../../src/qnevb/: led.c button.c
  group retarget
    ../../src/retarget/: retarget.c
